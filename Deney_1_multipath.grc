options:
  parameters:
    generate_options: qt_gui
    id: Deney_1_multipath
    output_language: python
    title: Digital Modulation
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '32'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: Phase:Bandwidth
    start: '0'
    step: '0.01'
    stop: '1'
    value: 6.28/100.0
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    npwr: '0.5'
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.5+1.0j]'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Pc\Desktop\file.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Pc\Desktop\file.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: taps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0, 0, 1, 1
    name: '"Before Equalizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0, 1, 1, 1
    name: '"After Equalizer"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1, 0, 1, 2
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_delay_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_file_source_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [channels_channel_model_0, '0', digital_linear_equalizer_0, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', channels_channel_model_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
